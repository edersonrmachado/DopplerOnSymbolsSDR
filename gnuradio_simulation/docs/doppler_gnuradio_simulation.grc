options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL, Jonas Feijó (modified by Ederson Machado)
    description: Simulation of doppler effect impact on a sequence of LoRa symbols
    generate_options: no_gui
    id: doppler_gnuradio_simulation
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    comment: Bandwidth
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 436.9e6
  states: {}
- name: clk_offset
  id: variable
  parameters:
    comment: Clock offset in ppm
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    comment: |-
      Coding
      Rate
    value: '1'
  states: {}
- name: doppler_rate
  id: variable
  parameters:
    value: '-140.28'
  states: {}
- name: doppler_shift
  id: variable
  parameters:
    value: '0'
  states: {}
- name: file_to_save_samples
  id: variable
  parameters:
    value: '"../data/fft_test.txt"'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldro
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: |-
      Spreading 
      Factor
    value: '10'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: symbol
  id: variable
  parameters:
    value: '512'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    minoutbuf: 2**sf*5
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: int
    vector: '[symbol]*(pay_len+2)'
  states: {}
- name: doppler_modulate_doppler_0
  id: doppler_modulate_doppler
  parameters:
    bw: bw
    doppler_rate: int(doppler_rate)
    doppler_shift: '0'
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '18'
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '0'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    filename: file_to_save_samples
    max_log_approx: 'False'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/(bw))
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: ldro
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/(2*samp_rate/(bw))
    decim: int(samp_rate/bw)
    gain: '1'
    minoutbuf: 2**sf*5
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 15e3
    win: window.WIN_HAMMING
  states: {state: disabled}

connections:
- [blocks_throttle_1, '0', lora_sdr_frame_sync_0, '0']
- [blocks_throttle_1, '0', low_pass_filter_0, '0']
- [blocks_vector_source_x_0, '0', doppler_modulate_doppler_0, '0']
- [doppler_modulate_doppler_0, '0', blocks_throttle_1, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [low_pass_filter_0, '0', lora_sdr_frame_sync_0, '0']

metadata:
  file_format: 1
